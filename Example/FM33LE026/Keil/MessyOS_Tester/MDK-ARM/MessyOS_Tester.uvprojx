# Keil uVision project MessyOS_Tester.uvprojx, settings and files
target Example (6140000::V6.14::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: MessyOS_Tester +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FM33LE0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Config\Inc;..\Inc;..\Drivers\FM33LE0xx_FL_Driver\Inc;..\..\..\..\..\Source\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33le0xx.s
  group Application/MF-config
    ../Config/Src/: mf_config.c
    ../Src/: uart0_DMAtx.c
  group Application/User
    ../Src/: main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33le0xx.c
  group Drivers/FM33LE0xx_FL_Driver
    ../Drivers/FM33LE0xx_FL_Driver/Src/: fm33le0xx_fl.c fm33le0xx_fl_aes.c fm33le0xx_fl_atim.c fm33le0xx_fl_bstim32.c fm33le0xx_fl_comp.c fm33le0xx_fl_crc.c fm33le0xx_fl_divas.c fm33le0xx_fl_dma.c fm33le0xx_fl_exti.c fm33le0xx_fl_flash.c fm33le0xx_fl_gpio.c fm33le0xx_fl_gptim.c fm33le0xx_fl_i2c.c fm33le0xx_fl_iwdt.c fm33le0xx_fl_lcd.c fm33le0xx_fl_lptim32.c fm33le0xx_fl_lpuart.c fm33le0xx_fl_pmu.c fm33le0xx_fl_rcc.c fm33le0xx_fl_rng.c fm33le0xx_fl_rtc.c fm33le0xx_fl_spi.c fm33le0xx_fl_svd.c fm33le0xx_fl_u7816.c fm33le0xx_fl_uart.c fm33le0xx_fl_wwdt.c fm33le0xx_fl_i2csmb.c fm33le0xx_fl_adc.c
  group MessyOS
    ../../../../../Source/ArmCore/: mes_sys.c mes_systick.c
    ../../../../../Source/osKernal/: mes_list.c mes_queue.c messyos.c messyos.s
